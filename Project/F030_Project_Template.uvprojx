# Keil uVision project F030_Project_Template.uvprojx, settings and files
target STM32F030 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F030K6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: F030_Project_Template
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F030
  c include: ..\Libraries\CMSIS;..\Libraries\FWlib\inc;..\user;..\user\Led_Device;..\user\SysTick;..\user\USART;..\user\SPI_Device;..\user\OLED_Device;..\user\Adc_Device;..\user\Data_Structure;..\user\Data_pack;..\user\Bluetooth;..\user\Data_Structure\SeqQueue;..\user\Run_task;..\user\ST_string;..\user\SHT2X;..\user\I2C;..\user\key;..\user\USB_DET;..\user\TIM;..\user\TGS2600;..\user\STM32_ChipID;..\user\LowPower;..\user\power_ctl
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Start_up
    ../Libraries/CMSIS/startup/: startup_stm32f030.s
  group FWlib
    ../Libraries/FWlib/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group CMSIS
    ../Libraries/CMSIS/: system_stm32f0xx.c
  group Led_Device
    ../user/Led_Device/: Led_Device.c
  group key
    ../user/key/: key_driver.c
  group SysTick
    ../user/SysTick/: SysTick.c
  group USART
    ../user/USART/: usart_device.c
  group SPI_Device
    ../user/SPI_Device/: SPI_Device.c
  group OLED_Device
    ../user/OLED_Device/: OLED_Device.c
  group Adc_Device
    ../user/Adc_Device/: Adc_Device.c
  group Bluetooth
    ../user/Bluetooth/: Bluetooth.c
  group SHT2X
    ../user/SHT2X/: SHT2x.c
  group Usb_Det
    ../user/USB_DET/: usb_Det.C
  group I2C
    ../user/I2C/: i2c_driver.c
  group TIM
    ../user/TIM/: tim_driver.c
  group TGS2600
    ../user/TGS2600/: TGS2600_driver.c
  group LowPower
    ../user/LowPower/: LowPower.c
  group STM32_ChipID
    ../user/STM32_ChipID/: STM32_ChipID.c
  group Data_Pack
    ../user/Data_pack/: data_pack.c
  group Data_structure
    ../user/Data_Structure/: Data_Structure.c
    ../user/Data_Structure/SeqQueue/: SeqList.c SeqQueue.c
  group Run_task
    ../user/Run_task/: Run_task.c
  group ST_string
    ../user/ST_string/: ST_string.c
  group User
    ../user/: main.c stm32f0xx_it.c
    ../user/power_ctl/: power_ctl.c
  group Doc
    ../Doc/: readme.txt
